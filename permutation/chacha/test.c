
// define GX to use version of ChaCha20 described in:
// https://tools.ietf.org/rfc/rfc8439.txt

#include <string.h>
#include <stdlib.h>
#include <stdint.h>
#include <stdio.h>

#include "chacha20.h"

#ifdef GX
// 2.4.2.  Example and Test Vector for the ChaCha20 Cipher
uint8_t tv_key[]=
{ 0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,
  0x08,0x09,0x0a,0x0b,0x0c,0x0d,0x0e,0x0f,
  0x10,0x11,0x12,0x13,0x14,0x15,0x16,0x17,
  0x18,0x19,0x1a,0x1b,0x1c,0x1d,0x1e,0x1f };
      
uint8_t tv_nonce[]=
{ 0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4a,
  0x00,0x00,0x00,0x00 };

// Plaintext Sunscreen:
uint8_t tv_plaintext[]=
{ 0x4c,0x61,0x64,0x69,0x65,0x73,0x20,0x61,
  0x6e,0x64,0x20,0x47,0x65,0x6e,0x74,0x6c,
  0x65,0x6d,0x65,0x6e,0x20,0x6f,0x66,0x20,
  0x74,0x68,0x65,0x20,0x63,0x6c,0x61,0x73,
  0x73,0x20,0x6f,0x66,0x20,0x27,0x39,0x39,
  0x3a,0x20,0x49,0x66,0x20,0x49,0x20,0x63,
  0x6f,0x75,0x6c,0x64,0x20,0x6f,0x66,0x66,
  0x65,0x72,0x20,0x79,0x6f,0x75,0x20,0x6f,
  0x6e,0x6c,0x79,0x20,0x6f,0x6e,0x65,0x20,
  0x74,0x69,0x70,0x20,0x66,0x6f,0x72,0x20,
  0x74,0x68,0x65,0x20,0x66,0x75,0x74,0x75,
  0x72,0x65,0x2c,0x20,0x73,0x75,0x6e,0x73,
  0x63,0x72,0x65,0x65,0x6e,0x20,0x77,0x6f,
  0x75,0x6c,0x64,0x20,0x62,0x65,0x20,0x69,
  0x74,0x2e };
  
// Ciphertext Sunscreen:
uint8_t tv_stream[]=
{ 0x6e,0x2e,0x35,0x9a,0x25,0x68,0xf9,0x80,
  0x41,0xba,0x07,0x28,0xdd,0x0d,0x69,0x81,
  0xe9,0x7e,0x7a,0xec,0x1d,0x43,0x60,0xc2,
  0x0a,0x27,0xaf,0xcc,0xfd,0x9f,0xae,0x0b,
  0xf9,0x1b,0x65,0xc5,0x52,0x47,0x33,0xab,
  0x8f,0x59,0x3d,0xab,0xcd,0x62,0xb3,0x57,
  0x16,0x39,0xd6,0x24,0xe6,0x51,0x52,0xab,
  0x8f,0x53,0x0c,0x35,0x9f,0x08,0x61,0xd8,
  0x07,0xca,0x0d,0xbf,0x50,0x0d,0x6a,0x61,
  0x56,0xa3,0x8e,0x08,0x8a,0x22,0xb6,0x5e,
  0x52,0xbc,0x51,0x4d,0x16,0xcc,0xf8,0x06,
  0x81,0x8c,0xe9,0x1a,0xb7,0x79,0x37,0x36,
  0x5a,0xf9,0x0b,0xbf,0x74,0xa3,0x5b,0xe6,
  0xb4,0x0b,0x8e,0xed,0xf2,0x78,0x5e,0x42,
  0x87,0x4d }; 

#else
// 256-bit key
uint8_t tv_key[32] = {
  0xf0, 0xb2, 0x48, 0x1d, 0x6b, 0x24, 0xd0, 0x18,
  0x03, 0x6a, 0x9e, 0x3d, 0x03, 0xc9, 0x7b, 0x1d,
  0x9e, 0x4b, 0x46, 0x6b, 0x01, 0x7d, 0xde, 0x25,
  0xcb, 0x9c, 0x6a, 0x00, 0xfa, 0xda, 0xac, 0x11 };

// 64-bit nonce
uint8_t tv_nonce[8] = {
  0x1b, 0xec, 0x52, 0xf7, 0xfc, 0xcc, 0x95, 0x24 };

// 512-bit stream after 2048 blocks of keystream
uint8_t tv_stream[64] = {
  0x97, 0x9d, 0x8e, 0x1f, 0xe7, 0x51, 0xb3, 0xba, 
  0xb0, 0x8e, 0x95, 0x59, 0x62, 0xb8, 0x30, 0x67, 
  0x19, 0x03, 0x06, 0xb5, 0xc6, 0xf3, 0x4c, 0x56, 
  0xc2, 0x37, 0xe2, 0x77, 0x10, 0xf1, 0xb9, 0x50, 
  0x73, 0x03, 0xd7, 0x41, 0x2e, 0x7b, 0xf3, 0xf5, 
  0xba, 0xa9, 0x41, 0xc6, 0x5c, 0xde, 0x2c, 0x1f, 
  0xee, 0xca, 0x5b, 0x26, 0x3a, 0x9b, 0x56, 0x1b, 
  0x50, 0xd1, 0x16, 0xd0, 0xfc, 0xba, 0xb6, 0x07 };

#endif

// 512-bit output after 2048 iterations of permutation function
uint8_t tv_perm[64] = {
  0x0e, 0x3f, 0x8e, 0x6e, 0xf7, 0x87, 0x07, 0x95, 
  0xdb, 0xb6, 0x03, 0x09, 0xaa, 0x0e, 0x55, 0x7d, 
  0xf7, 0xa3, 0xd2, 0x86, 0x90, 0x6d, 0xc7, 0xc3, 
  0x70, 0x24, 0x47, 0x34, 0x3f, 0x38, 0x2e, 0xa4, 
  0x4c, 0xe0, 0x40, 0xf1, 0x05, 0xe5, 0x53, 0x8b, 
  0xd1, 0xab, 0x53, 0x76, 0x9d, 0xf6, 0x46, 0x82, 
  0x63, 0xbc, 0x07, 0x21, 0x7f, 0x7a, 0x2d, 0x5c, 
  0xf7, 0x38, 0x6d, 0xed, 0x09, 0x3a, 0x87, 0x0d };
  
void bin2hex(const char *s, void *bin, int len) {
    int  i;
    char c;
    uint8_t *b=bin;
    
    printf ("\n%s=", s);
    
    for (i=0; i<len; i++) {
      if ((i & 7)==0) putchar('\n');
      if (i==len-1) c='\n'; else c=',';
      printf ("0x%02x%c ", b[i], c);
    }
}

int main(void) {
    uint8_t    state[64], stream[1024];
    chacha_ctx ctx;
    int        i, equ;
    
    // test the permutation function first
    for(i=0;i<64;i++) state[i]=(i+1);
    
    for(i=0;i<2048;i++) {
      chacha20_core((uint32_t*)state, (uint32_t*)stream);
    }
    equ = (memcmp(stream, tv_perm, 64)==0);

    printf("chacha20 core test : %s\n", equ ? "OK" : "FAILED");

    chacha20_setkey(&ctx, tv_key, tv_nonce);
    
  #ifdef GX
    memcpy(stream, tv_plaintext, sizeof(tv_plaintext));
    chacha20_encrypt(&ctx, stream, sizeof(tv_plaintext));
  #else
    for(i=0;i<2048;i++) {
      chacha20_keystream(&ctx, stream, 64);
    }
  #endif
  
    equ = (memcmp(stream, tv_stream, 64)==0);
    printf("chacha20 keystream test : %s\n", equ ? "OK" : "FAILED");
    return 0;
}
