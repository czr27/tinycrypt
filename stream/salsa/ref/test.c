

#include <string.h>
#include <stdlib.h>
#include <stdint.h>
#include <stdio.h>

#include "ecrypt-sync.h"

// 256-bit key
u8 tv_key[32] = {
  0xf0, 0xb2, 0x48, 0x1d, 0x6b, 0x24, 0xd0, 0x18,
  0x03, 0x6a, 0x9e, 0x3d, 0x03, 0xc9, 0x7b, 0x1d,
  0x9e, 0x4b, 0x46, 0x6b, 0x01, 0x7d, 0xde, 0x25,
  0xcb, 0x9c, 0x6a, 0x00, 0xfa, 0xda, 0xac, 0x11 };

// 64-bit nonce
u8 tv_nonce[8] = {
  0x1b, 0xec, 0x52, 0xf7, 0xfc, 0xcc, 0x95, 0x24 };
  
// 512-bit stream after 2048 iterations
u8 tv_ct[64] = {
  0xe9, 0xbd, 0xc7, 0xca, 0x97, 0x6d, 0x58, 0x65, 
  0xcb, 0xec, 0x12, 0x13, 0x5f, 0xa6, 0x25, 0x7d, 
  0xd0, 0x9d, 0x43, 0x7e, 0x13, 0x76, 0x44, 0xd9, 
  0xce, 0x4e, 0x06, 0x97, 0x5e, 0x80, 0x2c, 0x88, 
  0x5d, 0x72, 0x5b, 0x8e, 0xcb, 0x47, 0x78, 0xa2, 
  0x60, 0x9b, 0x2f, 0xfe, 0x0c, 0xf5, 0x04, 0x84, 
  0x25, 0x2c, 0x31, 0xda, 0xa8, 0x25, 0x39, 0x7f, 
  0x4c, 0x89, 0xaf, 0xba, 0x5c, 0x2e, 0x75, 0xa7 };

void bin2hex(const char *s, u8 b[], int len) {
    int  i;
    char c;
    
    printf ("\n%s=", s);
    for (i=0; i<len; i++) {
      if ((i & 7)==0) putchar('\n');
      if (i==len-1) c='\n'; else c=',';
      printf ("0x%02x%c ", b[i], c);
    }
}

void salsa20_wordtobyte(u8 output[64],const u32 input[16]);

int main(void) {
    u8         output[64], stream[64];
    ECRYPT_ctx ctx;
    int        i;
    
    // test the permutation first
    for(i=0;i<64;i++) stream[i]=(i+1);
    
    for(i=0;i<2048;i++) {
      salsa20_wordtobyte(output, (u32*)stream);
    }
    bin2hex("permutation result", output, 64);
      
    memset(&ctx, 0, sizeof(ctx));
    
    ECRYPT_keysetup(&ctx, tv_key, 256, 64);
    ECRYPT_ivsetup(&ctx, tv_nonce);
    
    for(i=0;i<2048;i++) {
      ECRYPT_keystream_bytes(&ctx, stream, 64);
    }
    
    bin2hex("stream result", stream, 64);
    return 0;
}
